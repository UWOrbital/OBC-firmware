options:
  parameters:
    generate_options: qt_gui
    id: Soapy2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '433932000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: soapy.out
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from PyQt5 import Qt
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: '10000'
    center_freq: frequency
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_correctiq_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
